#include <iostream>
#include <fstream>
#include <math.h>
using namespace std;
int64_t a,b,n,k,c[100000],d[100000],ans;
bool Ok;
     //=====================================================================================================================================
     void Doc()
     {
         freopen("MODULO.inp","r",stdin);
         freopen("MODULO.out","w",stdout);
         cin.tie(NULL); cout.tie(NULL);
         cin>>a>>b>>n>>k;
     }
     //=====================================================================================================================================
     bool K_T(int64_t x)
     {
         int64_t t=pow(2,n);
         if (x%t==k) return true;
         else return false;
     }
     //=====================================================================================================================================
     void Xu_Ly()
     {
         int64_t i,x=0;
         for (i=1;i<=n;i++)
         {
             x+=c[i];
             x*=10;
         }
         x/=10;
         if (K_T(x))
         {
             Ok=true;
             cout<<x;
         }
     }
     //=====================================================================================================================================
     void Test(int64_t i)
     {
        int j;
        if (i>n) Xu_Ly();
        else
        for (j=0;j<=1;j++)
        {
           if (j==0) c[i]=a;
           if (j==1) c[i]=b;
           Test(i+1);
        }
     }
     //=====================================================================================================================================
     int main()
     {
         Ok=false;
         Doc();
         Test(1);
         if(!Ok) cout<<-1;
     }
